# Keil uVision project Car.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: C:\Users\Coward\Desktop\CarFreeRTOS\keil5_disp_size_bar.exe
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\APP;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c board.c mytask.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c
  group APP
    ./APP/: bluetooth_module.c k210_module.c motor_module.c tracking_module.c ultrasonic_wave_module.c wifi_module.c mpu6050_module.c
  group Public
    ./Public/: system.c SysTick.c usart.c pwm.c
  group FreeRTOS_core
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group FreeRTOS_port
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
